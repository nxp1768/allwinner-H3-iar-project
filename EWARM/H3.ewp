# IAR project H3.ewp, settings and files
configuration H3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429AI ST STM32F429AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCIncludePath2: ../Inc; F:\ti_2017\H3\H3; F:\ti_2017\H3\H3\gTouch
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: H3.bin
  ILINK.IlinkOutputFile: H3.out
  ILINK.IlinkIcfFile: 666.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: cp15.S startup_H3.s
  group Application/User
    ../Src/: main.c
  group Drivers
    ../Src/usb/: cache_cp15.c cache_v7.c gpio.c mmu.c sunxi_dma.c usb_base_80.c usb_dma_control.c usb_fastboot.c usbc.c usbc_dev.c usbc_dma.c usbc_resource.c
    ../Src/: ccmu.c clock.c gic.c interrupts.c spi_hal.c timer.c uart.c
